FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://aic8800.cfg"